export DISABLE_HOTSPOT_OS_VERSION_CHECK = "y"
